# Keil uVision project iSO-STM32.uvprojx, settings and files
target STM32_DEMO (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER ,PLATFORM=SX12xxEiger
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\SysTick;..\..\User\SX1278;..\..\User\SX1278\radio;..\..\User\SX1278\platform\bleeper;..\..\User\SX1278\platform\sx1200dvk;..\..\User\SX1278\platform\sx1243ska;..\..\User\SX1278\platform\sx12xxEiger;..\..\User\SX1278\platform;..\..\User\MPU6050;..\..\User\MPU6050\eMPL;..\..\User\SYSTEM\delay;..\..\User\SYSTEM\sys;..\..\User\SYSTEM\usart;..\..\User\ADC;..\..\User\motor;..\..\User\KEY;..\..\User\WDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h sys_config.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/usart/: bsp_usart.c
  group radio
    ../../User/SX1278/radio/: radio.c sx1232.c sx1232-Misc.c sx1272.c sx1272-Fsk.c sx1272-FskMisc.c sx1272-LoRa.c sx1272-LoRaMisc.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group sx12xxEiger
    ../../User/SX1278/platform/sx12xxEiger/: fifo.c spi.c sx12xxEiger.c sx1232-Hal.c sx1272-Hal.c sx1276-Hal.c
  group MPU6050
    ../../User/MPU6050/: mpu6050.c mpuiic.c
    ../../User/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group ADC
    ../../User/ADC/: adc.c
  group motor
    ../../User/motor/: motor.c
  group KEY
    ../../User/KEY/: key.c
  group SYSTEM
    ../../User/SYSTEM/delay/: delay.c
    ../../User/SYSTEM/sys/: sys.c
    ../../User/SYSTEM/usart/: usart.c
  group DOC
    ../../Doc/: readme.txt
  group WDG
    ../../User/WDG/: wdg.c
software components: CMSIS:CORE 4.3.0
